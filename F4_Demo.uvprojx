# Keil uVision project F4_Demo.uvprojx, settings and files
target Demo_project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\core;.\HAL\STM32F4xx_HAL_Driver\Inc;.\HAL\STM32F4xx_HAL_Driver\Inc\Legacy;.\User;.\HAL;.\Sys
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HAL
    ./HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Startup
    ./HAL/: startup_stm32f407xx.s
  group Config
    ./HAL/: stm32f4xx_hal_conf.h
    ./Sys/: def.h
  group Sys
    ./Sys/: base.h Sys.c Sys.h gpio.c gpio.h time.c time.h uart.c uart.h
  group User
    ./User/: main.c stm32f4xx.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h stm32f407xx.h system_stm32f4xx.c system_stm32f4xx.h
  group ReadME
    ./ReadME/: ReadMe.txt
